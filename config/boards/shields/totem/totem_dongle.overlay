/*
 * Copyright (c) 2024 The ZMK Contributors
 *
 * SPDX-License-Identifier: MIT
 */

#include <dt-bindings/zmk/matrix_transform.h>
#include "totem-layouts.dtsi"

/ {
    chosen {
        zephyr,display = &st7789;
        zmk,kscan = &mock_kscan;
        zmk,physical-layout = &physical_layout0;
        /* C 코드(brightness.c)가 백라이트 핀을 인식하도록 설정 */
        zmk,backlight = &led_backlight;
    };

    /* 백라이트 핀을 별도 LED 노드로 분리 (드라이버 에러 방지) */
    backlight: backlight {
        compatible = "gpio-leds";
        led_backlight: led_backlight {
            gpios = <&xiao_d 6 GPIO_ACTIVE_HIGH>;
        };
    };

    default_transform: keymap_transform_0 {
        compatible = "zmk,matrix-transform";
        columns = <10>;
        rows = <4>;
        map = <
                RC(0,0) RC(0,1) RC(0,2) RC(0,3) RC(0,4)    RC(0,5) RC(0,6) RC(0,7) RC(0,8) RC(0,9)
                RC(1,0) RC(1,1) RC(1,2) RC(1,3) RC(1,4)    RC(1,5) RC(1,6) RC(1,7) RC(1,8) RC(1,9)
        RC(3,0) RC(2,0) RC(2,1) RC(2,2) RC(2,3) RC(2,4)    RC(2,5) RC(2,6) RC(2,7) RC(2,8) RC(2,9) RC(3,9)
                                RC(3,2) RC(
